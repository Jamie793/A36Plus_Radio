# Keil uVision project Project.uvprojx, settings and files
target Project (6070000::V6.7::.\ARMCLANG)
  device: GD32F330CB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F3X0,GD32F330
  c include: ..\Libraries\GD32\CMSIS\GD\GD32F3x0\Include;..\Libraries\GD32\CMSIS\Keil;..\Users\Inc;..\Libraries\GD32\CMSIS\GD\GD32F3x0\Source\ARM;..\Libraries\GD32\GD32F3x0_standard_peripheral\Include;.cmsis\include;RTE\_GD32F330;.eide\deps;..\Libraries\GD32;..\Core\Inc;..\Drivers\LCD;..\Drivers\Flash;..\Drivers\BK4819;..\Drivers\BK1080;..\Drivers\Key
  asm define: USE_STDPERIPH_DRIVER,GD32F3X0,GD32F330
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group ../USERS/SRC
    ../Users/Src/: boot.c gd32f3x0_it.c main.c systick.c
  group ../CORE/SRC
    ../Core/Src/: dma.c gpio.c spi.c usart.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/HOST/CORE/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/HOST/CLASS/MSC/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/HOST/CLASS/HID/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DRIVER/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/driver/Source/: drv_usbd_int.c drv_usbh_int.c drv_usb_core.c drv_usb_dev.c drv_usb_host.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CORE/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CLASS/PRINTER/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/class/printer/Source/: printer_core.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CLASS/MSC/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CLASS/IAP/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/class/iap/Source/: usb_iap_core.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CLASS/HID/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/class/hid/Source/: custom_hid_core.c standard_hid_core.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CLASS/DFU/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/class/dfu/Source/: dfu_core.c dfu_mem.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CLASS/CDC/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group ../LIBRARIES/GD32/GD32F3X0_USBFS_LIBRARY/DEVICE/CLASS/AUDIO/SOURCE
    ../Libraries/GD32/GD32F3x0_usbfs_library/device/class/audio/Source/: audio_core.c audio_out_itf.c
  group ../LIBRARIES/GD32/GD32F3X0_STANDARD_PERIPHERAL/SOURCE
    ../Libraries/GD32/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group ../LIBRARIES/GD32/CMSIS/GD/GD32F3X0/SOURCE
    ../Libraries/GD32/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group ../LIBRARIES/GD32/CMSIS/GD/GD32F3X0/SOURCE/IAR
    ../Libraries/GD32/CMSIS/GD/GD32F3x0/Source/IAR/: startup_gd32f3x0.s
  group ../LIBRARIES/GD32/CMSIS/GD/GD32F3X0/SOURCE/GNU
    ../Libraries/GD32/CMSIS/GD/GD32F3x0/Source/GNU/: startup_gd32f3x0.s
  group ../LIBRARIES/GD32/CMSIS/GD/GD32F3X0/SOURCE/ARM
    ../Libraries/GD32/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group ../DRIVERS/LCD
    ../Drivers/LCD/: fonts.c gfx.c st7735s.c st7735s_compat.c
  group ../DRIVERS/FLASH
    ../Drivers/Flash/: w25q16jv.c
  group ../DRIVERS/BK4819
    ../Drivers/BK4819/: bk4819.c
  group ../DRIVERS/BK1080
    ../Drivers/BK1080/: bk1080.c
